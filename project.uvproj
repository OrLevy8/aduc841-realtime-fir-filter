# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC841 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: aduc841_fir_filter +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  asm include: .\src
  group Source Group 1
    ./src/: circular_buffer.c filter_taps.c filter_taps.h lab7_main.c peripherals.c peripherals.h
